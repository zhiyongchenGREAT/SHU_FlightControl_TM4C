# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCIncludePath2: ..\OS_Support\ucOSIII\Source; ..\OS_Support\ucOSIII\Ports; ..\OS_Support\ucOSIII_BSP; ..\OS_Support\ucOSIII_CONFIG; ..\OS_Support\ucOSIII_CPU; ..\OS_Support\ucOSIII_CPU\ARM-Cortex-M4\IAR; ..\OS_Support\ucOSIII_LIB; ..\Board_Support; ..\Basic_Flight_Code\app; ..\Basic_Flight_Code\app\openpilot; ..\Basic_Flight_Code\app\openpilot\Data; ..\Basic_Flight_Code\app\openpilot\math; ..\Basic_Flight_Code\app\openpilot\Param; ..\Basic_Flight_Code\board; ..\Basic_Flight_Code\chip; ..\Application_Code\Main_TM4C; ..\Application_Code\Fuctional_Modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application_Code/Functional_Modules
    ../Application_Code/Fuctional_Modules/: app_includes.h core_autopilot.c core_camera.c core_ppm.c core_t_timer.c core_uart.c core_uartstdio.c eepromqsj.c flight_routine.c Pic_hold.c renesas_interface.c
  group Application_Code/Main_TM4C
    ../Application_Code/Main_TM4C/: CORE_TASK.c CORE_TASK1.c CORE_TASK2.c CORE_TASK3.c TM4C.c
  group Basic_Flight_Code/app/OpenPilot
    ../Basic_Flight_Code/app/openpilot/: attitudesolving_B.c basicflight_includes.h control_command_B.c data_common.c data_transfer.c hold.c mixer.c motor_control.c param_common.c Postion_Hold.c relay_tuning.c sensorfetch.c stabilization_B.c virtualflybar.c
  group Basic_Flight_Code/app/OpenPilot/Data
    ../Basic_Flight_Code/app/openpilot/Data/: acceldesired.h accels.h accessorydesired.h actuatorcommand.h actuatordesired.h attitudeactual.h attitudesensor.h flightbatterystate.h flightstatus.h gyros.h gyrosbias.h manualcontrolcommand.h mixerstatus.h nrf_data.h ratedesired.h relaytuning.h stabilizationdesired.h state_struct.h timestamp.h trimangles.h uart_data.h
  group Basic_Flight_Code/app/OpenPilot/Math
    ../Basic_Flight_Code/app/openpilot/math/: atmospheric_math.c coordinate_conversions.c math_includes.h misc_math.c physical_constants.h pid.c sin_lookup.c
  group Basic_Flight_Code/app/OpenPilot/Param
    ../Basic_Flight_Code/app/openpilot/Param/: actuatorsettings.h attitudesettings.h manualcontrolsettings.h mixersettings.h motorsettings.h relaytuningsettings.h sensorsettings.h stabilizationsettings.h systemsettings.h
  group Basic_Flight_Code/board
    ../Basic_Flight_Code/board/: device_includes.h Flow_B.c KS103.c YRK_AK8975_SOFT.c YRK_init.c YRK_LED.c YRK_MPU6050_SOFT.c YRK_NRF24L0.c YRK_SONAR.c
  group Basic_Flight_Code/chip
    ../Basic_Flight_Code/chip/: board_includes.h core_common.c core_common.h
  group Board_Support/driverlib
    ../Board_Support/driverlib/: adc.c can.c comp.c cpu.c eeprom.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group OS_Support/ucOSIII
    ../OS_Support/ucOSIII/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group OS_Support/ucOSIII_BSP
    ../OS_Support/ucOSIII_BSP/: bsp.c bsp_int.c bsp_sys.c cpu_bsp.c
  group OS_Support/ucOSIII_BSP/STARTUP
    ../OS_Support/ucOSIII_BSP/IAR/: project.icf startup_ewarm.c
  group OS_Support/ucOSIII_CONFIG
    ../OS_Support/ucOSIII_CONFIG/: app_cfg.h bsp_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h OS_includes.h
  group OS_Support/ucOSIII_CPU
    ../OS_Support/ucOSIII_CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../OS_Support/ucOSIII_CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group OS_Support/ucOSIII_LIB
    ../OS_Support/ucOSIII_LIB/: lib_ascii.c lib_def.h lib_math.c lib_mem.c lib_str.c
    ../OS_Support/ucOSIII_LIB/Ports/: lib_mem_a.asm
  group OS_Support/ucOSIII_PORT
    ../OS_Support/ucOSIII/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
